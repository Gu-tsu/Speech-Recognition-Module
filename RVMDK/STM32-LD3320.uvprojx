# Keil uVision project STM32-LD3320.uvprojx, settings and files
target STM32-LD3320-Driver (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-LD3320 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\M3lib\inc;..\user;..\LD_Driver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../user/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../M3lib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c
  group CMSIS
    ../user/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../startup/: startup_stm32f10x_hd.s
  group LD3320 \Driver
    ../LD_Driver/: LD3320_main.c LDChip.c Reg_RW.c
  group other
    ../user/: LEDtest.C
software components: CMSIS:CORE 5.0.1
